# Keil uVision project ucosii.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ucosii +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F401xx,USE_STDPERIPH_DRIVER
  c include: ..\BSP;..\CONFIG;..\CORE;..\PORT;..\BSP\inc;..\LIB\inc;..\APP;..\HAL;..\uC-LIB;..\uC-CPU;..\SEGGER;..\OS;..\SEGGER\Syscalls
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group CORE
    ../CORE/: os_core.c os_dbg_r.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group PORT
    ../PORT/: os_cpu.h os_cpu_c.c os_cpu_a.asm
  group CONFIG
    ../CONFIG/: app_cfg.h os_cfg.h Global.h includes.h SEGGER_RTT_Conf.h SEGGER_SYSVIEW_Conf.h
  group BSP
    ../HAL/: stm32f4xx_it.c
    ../BSP/src/: startup_stm32f401xx.s system_stm32f4xx.c
  group APP
    ../HAL/: sysTick.c
    ../APP/: main.c hm10.c hmc5883l.c LED.c motor.c mpu6050.c oled.c receiver.c codetab.c
  group LIB
    ../LIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group HAL
    ../HAL/: i2c.c tim.c USART.c
  group SEGGER
    ../SEGGER/: SEGGER_SYSVIEW_Int.h SEGGER.h SEGGER_RTT.c SEGGER_RTT.h SEGGER_SYSVIEW.c SEGGER_SYSVIEW.h SEGGER_SYSVIEW_ConfDefaults.h
  group OS
    ../OS/: os_cfg_trace.h os_trace_events.h SEGGER_SYSVIEW_Config_uCOSII.c SEGGER_SYSVIEW_uCOSII.c
