# Keil uVision project ucOSii_F411.uvprojx, settings and files
target ucOSii_F411 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: ucOSii_F411 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\uCOS\config;..\uCOS\core;..\uCOS\port;..\SystemView\Config;..\SystemView\SEGGER;..\SystemView\uCOS-II;..\SystemView\uCOS-II\Config;..\Hardware\inc;..\APP\inc;..\DMP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group uCOS-core
    ../uCOS/core/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS-port
    ../uCOS/port/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group uCOS-config
    ../uCOS/config/: includes.h os_cfg.h
  group SystemView
    ../SystemView/SEGGER/Syscalls/: SEGGER_RTT_Syscalls_GCC.c SEGGER_RTT_Syscalls_IAR.c SEGGER_RTT_Syscalls_SES.c
    ../SystemView/SEGGER/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_SYSVIEW.c
    ../SystemView/uCOS-II/: SEGGER_SYSVIEW_uCOSII.c
    ../SystemView/uCOS-II/Config/RX/: SEGGER_SYSVIEW_Config_uCOSII.c
  group Hardware
    ../Hardware/src/: controller.c esp8266.c gy-86.c motor.c oled.c
  group APP
    ../APP/src/: data_transfer.c
  group DMP
    ../DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
software components: CMSIS:CORE 5.5.0
